options:
  parameters:
    author: AeroLake
    description: Record a finite IQ capture from a REAL SDR (RTL-SDR, BladeRF, …) to a .sigmf-data file, via SoapySDR. Works with any SoapySDR device — set sdr_driver.
    generate_options: no_gui
    id: aerolake_record_sdr
    output_language: python
    run_options: run
    title: AeroLake Record (real SDR via SoapySDR)
  states: {}

blocks:
- name: sdr_driver
  id: variable
  parameters:
    comment: 'SoapySDR driver: "rtlsdr", "bladerf", "hackrf", … (one flowgraph, any SDR).'
    value: '"rtlsdr"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'Sample rate (Hz). RTL-SDR: <= ~2.4e6. BladeRF: up to 61e6 (needed for Starlink 25e6).'
    value: '2000000'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: Center frequency (Hz). GNSS L1 = 1575420000, Iridium = 1626000000.
    value: '1575420000'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: Manual RX gain (dB), used when agc is False.
    value: '40'
  states: {}
- name: agc
  id: variable
  parameters:
    comment: Automatic gain control on/off. True = let the SDR set the gain.
    value: 'True'
  states: {}
- name: n_samples
  id: variable
  parameters:
    comment: 'How many samples to record, then stop (here: 1 s at samp_rate).'
    value: '2000000'
  states: {}
- name: out_file
  id: variable
  parameters:
    comment: Output .sigmf-data path (raw cf32_le).
    value: '"/tmp/capture.sigmf-data"'
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    agc0: agc
    antenna0: '"RX"'
    center_freq0: freq
    comment: Any SoapySDR device (driver=sdr_driver). Outputs complex float32 (fc32).
    dc_removal0: 'False'
    driver: sdr_driver
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: Stop after n_samples — gives a finite recording.
    num_items: n_samples
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Write raw complex float32 — directly usable as a .sigmf-data blob.
    file: out_file
    type: complex
  states: {}

connections:
- [soapy_custom_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
