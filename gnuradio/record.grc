options:
  parameters:
    author: AeroLake
    description: Record a finite IQ capture to a .sigmf-data file (synthetic source until a real SDR is wired in).
    generate_options: no_gui
    id: aerolake_record
    output_language: python
    run_options: run
    title: AeroLake Record
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate (Hz).
    value: '2000000'
  states: {}
- name: n_samples
  id: variable
  parameters:
    comment: How many samples to record, then stop.
    value: '1000000'
  states: {}
- name: out_file
  id: variable
  parameters:
    comment: Output .sigmf-data path (raw cf32_le).
    value: '"/tmp/capture.sigmf-data"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    comment: Synthetic tone at 100 kHz, -20 dBFS (stand-in for a real SDR source).
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Pace generation at the sample rate, mimicking a real capture.
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: Stop after n_samples — gives a finite recording.
    num_items: n_samples
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Write raw complex float32 — directly usable as a .sigmf-data blob.
    file: out_file
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
