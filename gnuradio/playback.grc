options:
  parameters:
    author: AeroLake
    description: Replay a stored AeroLake .sigmf-data capture and view its spectrum.
    generate_options: qt_gui
    id: aerolake_playback
    output_language: python
    title: AeroLake Playback
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate (Hz) — match the capture's core:sample_rate.
    value: '2000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: RF center frequency (Hz) — for display only.
    value: '1575420000'
  states: {}
- name: capture_file
  id: variable
  parameters:
    comment: Path to a local .sigmf-data file (raw cf32_le).
    value: '"/tmp/capture.sigmf-data"'
  states: {}
- name: start_s
  id: variable
  parameters:
    comment: 'Partial read: start offset in seconds (0 = from the beginning).'
    value: '0'
  states: {}
- name: duration_s
  id: variable
  parameters:
    comment: 'Partial read: window length in seconds (0 = play to the end).'
    value: '0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'Read the capture as complex float32 (== cf32_le). offset/length give partial reading: start at start_s seconds, play duration_s seconds (0 = all).'
    file: capture_file
    length: int(duration_s * samp_rate)
    offset: int(start_s * samp_rate)
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Pace the file at the recorded sample rate (no real SDR here).
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"Spectrum"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color_map1: '"iron"'
    fc: center_freq
    fftsize: '1024'
    name: '"Spectrogram"'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
