options:
  parameters:
    author: AeroLake
    description: 'RE-EMIT a stored AeroLake .sigmf-data capture as REAL RF, via a BladeRF (SoapySDR TX). This is the hardware half of "playback": the file is the bridge (raw cf32_le). DANGER: transmitting on GNSS/Iridium bands over the air is illegal and jams real receivers — use a shielded cable, an attenuator, a dummy load or a Faraday enclosure.'
    generate_options: qt_gui
    id: aerolake_transmit_sdr
    output_language: python
    realtime_scheduling: 'True'
    title: AeroLake Transmit (re-emit a capture via BladeRF / SoapySDR)
  states: {}

blocks:
- name: sdr_driver
  id: variable
  parameters:
    comment: SoapySDR TX driver. The RTL-SDR is RX-only — TX needs a BladeRF (or HackRF/Pluto/LimeSDR).
    value: '"bladerf"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate (Hz) — MUST match the capture's core:sample_rate (Iridium test = 400000).
    value: '400000'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: TX center frequency (Hz) — match the capture's core:frequency (Iridium = 1626271000).
    value: '1626271000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: BladeRF TX gain (dB). START LOW. Into a cable/attenuator a few dB is plenty; never blast an antenna.
    value: '20'
  states: {}
- name: tx_amplitude
  id: variable
  parameters:
    comment: Digital backoff (0..1) before the DAC. The stored IQ is normalised to ~[-1, 1]; 0.8 leaves headroom so the DAC never clips.
    value: '0.8'
  states: {}
- name: capture_file
  id: variable
  parameters:
    comment: Local .sigmf-data file (raw cf32_le) — fetch it from MinIO with `aerolake-fetch --key <key> --out /tmp/capture.sigmf-data`.
    value: '"/tmp/capture.sigmf-data"'
  states: {}
- name: repeat
  id: variable
  parameters:
    comment: Loop the file forever (True) or transmit it once (False).
    value: 'False'
  states: {}
- name: start_s
  id: variable
  parameters:
    comment: 'Partial read: start offset in seconds (0 = from the beginning).'
    value: '0'
  states: {}
- name: duration_s
  id: variable
  parameters:
    comment: 'Partial read: how many seconds to transmit (0 = to the end).'
    value: '0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'Read the capture as complex float32 (== cf32_le). offset/length give partial transmit: start at start_s seconds, send duration_s seconds (0 = all).'
    file: capture_file
    length: int(duration_s * samp_rate)
    offset: int(start_s * samp_rate)
    repeat: repeat
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Digital amplitude backoff before the DAC (tx_amplitude in 0..1).
    const: tx_amplitude
    type: complex
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    antenna0: '"TX"'
    center_freq0: freq
    comment: Any SoapySDR TX device (driver=sdr_driver, default bladerf). The SDR clock paces the stream — no Throttle needed (and none wanted) with real hw.
    driver: sdr_driver
    gain0: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: Monitor what you are actually transmitting (a tap before the SDR).
    fc: freq
    fftsize: '1024'
    name: '"Transmitted spectrum"'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_custom_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
